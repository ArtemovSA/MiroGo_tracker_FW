# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG330F128 SiliconLaboratories EFM32LG330F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG330F128; BOOTLOADER
  ICCARM.CCIncludePath2: ..\Drivers\Flash; $PROJ_DIR$; ..\..\..\library\EFM32\CMSIS\Include; ..\..\..\library\EFM32\emlib\inc; ..\..\..\library\EFM32\emlib\src; ..; ..\Drivers\I2C; ..\Libs\CRC8; Delay; ..\..\..\library\EFM32\Device\SiliconLabs\EFM32LG\Include; ..\..\..\library\EFM32\Device\SiliconLabs\EFM32LG\Source\IAR; ..\..\..\library\EFM32\Device\SiliconLabs\EFM32LG\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: main.c
  group Drivers/Delay
    Delay/: Delay.c Delay.h
  group Drivers/I2C
    ../Drivers/I2C/: I2C.c I2C.h
  group EXT_Flash
    ../Drivers/Flash/: EXT_Flash.c EXT_Flash.h
  group Init
    ../: InitDevice.c InitDevice.h
  group Libs/CRC8
    ../Libs/CRC8/: CRC8.c CRC8.h
  group System/CMSIS
    ../../../library/EFM32/CMSIS/Include/: arm_math.h core_cm3.h
  group System/device/inc
    ../../../library/EFM32/Device/SiliconLabs/EFM32LG/Include/: efm32lg230f128.h efm32lg230f256.h efm32lg230f64.h efm32lg232f128.h efm32lg232f256.h efm32lg232f64.h efm32lg280f128.h efm32lg280f256.h efm32lg280f64.h efm32lg290f128.h efm32lg290f256.h efm32lg290f64.h efm32lg295f128.h efm32lg295f256.h efm32lg295f64.h efm32lg330f128.h efm32lg330f256.h efm32lg330f64.h efm32lg332f128.h efm32lg332f256.h efm32lg332f64.h efm32lg360f128.h efm32lg360f256.h efm32lg360f64.h efm32lg380f128.h efm32lg380f256.h efm32lg380f64.h efm32lg390f128.h efm32lg390f256.h efm32lg390f64.h efm32lg395f128.h efm32lg395f256.h efm32lg395f64.h efm32lg840f128.h efm32lg840f256.h efm32lg840f64.h efm32lg842f128.h efm32lg842f256.h efm32lg842f64.h efm32lg880f128.h efm32lg880f256.h efm32lg880f64.h efm32lg890f128.h efm32lg890f256.h efm32lg890f64.h efm32lg895f128.h efm32lg895f256.h efm32lg895f64.h efm32lg900f256.h efm32lg940f128.h efm32lg940f256.h efm32lg940f64.h efm32lg942f128.h efm32lg942f256.h efm32lg942f64.h efm32lg980f128.h efm32lg980f256.h efm32lg980f64.h efm32lg990f128.h efm32lg990f256.h efm32lg990f64.h efm32lg995f128.h efm32lg995f256.h efm32lg995f64.h efm32lg_acmp.h efm32lg_adc.h efm32lg_aes.h efm32lg_af_pins.h efm32lg_af_ports.h efm32lg_burtc.h efm32lg_burtc_ret.h efm32lg_calibrate.h efm32lg_cmu.h efm32lg_dac.h efm32lg_devinfo.h efm32lg_dma.h efm32lg_dma_ch.h efm32lg_dma_descriptor.h efm32lg_dmactrl.h efm32lg_dmareq.h efm32lg_ebi.h efm32lg_emu.h efm32lg_etm.h efm32lg_gpio.h efm32lg_gpio_p.h efm32lg_i2c.h efm32lg_lcd.h efm32lg_lesense.h efm32lg_lesense_buf.h efm32lg_lesense_ch.h efm32lg_lesense_st.h efm32lg_letimer.h efm32lg_leuart.h efm32lg_msc.h efm32lg_pcnt.h efm32lg_prs.h efm32lg_prs_ch.h efm32lg_prs_signals.h efm32lg_rmu.h efm32lg_romtable.h efm32lg_rtc.h efm32lg_timer.h efm32lg_timer_cc.h efm32lg_uart.h efm32lg_usart.h efm32lg_usb.h efm32lg_usb_diep.h efm32lg_usb_doep.h efm32lg_usb_hc.h efm32lg_vcmp.h efm32lg_wdog.h em_device.h system_efm32lg.h
  group System/device/src
    ../../../library/EFM32/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.c
    ../../../library/EFM32/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group System/Perefery lib/inc
    ../../../library/EFM32/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_bitband.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_common.h em_cryotimer.h em_crypto.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_idac.h em_int.h em_lcd.h em_ldma.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_part.h em_pcnt.h em_prs.h em_ramfunc.h em_rmu.h em_rtc.h em_rtcc.h em_system.h em_timer.h em_usart.h em_vcmp.h em_version.h em_wdog.h
  group System/Perefery lib/src
    ../../../library/EFM32/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
